Properties of the parts of a building model (IFC2X3)

# File
Description: Deckelset für Raumtemperaturregler RTBSU/FTR, BUSCH-JAEGER Reflex SI/SI linear, reinweiß (ähnl. RAL9010), glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990490, Deckelset für Raumtemperaturregler RTBSU/FTR, BUSCH-JAEGER Reflex SI/SI linear, reinweiß (ähnl. RAL9010), glänzend
In: Raum
Description: Die Unterputzgeräte von alre passen in Verbindung mit dem entsprechenden Deckelset (Abdeckung) in alle gängigen Schalterprogramme von BUSCH-JAEGER. Durch das Baukastenprinzip (alre Basisgerät + alre Deckelset für BUSCH-JAEGER + Rahmen von BUSCH-JAEGER) ist eine optisch perfekte Integration in Ihr favorisiertes Schalterprogramm möglich.; Classification: EC000011 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990490; ModelLabel: JZ-001.200/BJ; GlobalTradeItemNumber: 4050528074478; ProductURL: https://alre.de/produkt_G9990490
Pset_Specification - NominalLength: 0.054 m; NominalWidth: 0.054 m; NominalDepth: 0.011 m; NetWeight: 0.012
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 54; Ausführung: Zentralplatte; Halogenfrei: yes; Höhe: 54; Tiefe: 11; Oberflächenschutz: unbehandelt; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Befestigungsart: Schraubbefestigung; Aufdruck/Kennzeichnung: sonstige; Kontrollfenster/Lichtauslass: no; RAL-Nummer (ähnlich): 9010; Mit Beschriftungsfeld: no; Mit austauschbarer Linse/Symbol: no; Ausführung der Oberfläche: glänzend; Geeignet für Schutzart (IP): IP30; Geeignet für Bussystem-Tasterankopplung: no; Abtastbares Symbol/barrierefrei: no; ETIM-Klasse: EC000011; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990490.pdf
